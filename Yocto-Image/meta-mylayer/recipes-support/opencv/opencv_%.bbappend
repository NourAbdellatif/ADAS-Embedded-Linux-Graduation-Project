EXTRA_OECMAKE:append = " -DCMAKE_BUILD_TYPE=Release"
PACKAGECONFIG:append = " dnn"
