RPROVIDES:${PN} = "libcrypto.so.3(OPENSSL_3.0.0)(64bit) \
                   libssl.so.3(OPENSSL_3.0.0)(64bit) \
                   libssl.so.3()(64bit) \
                   libcrypto.so.3()(64bit)"

