inherit systemd
# Auto enable weston service
SYSTEMD_AUTO_ENABLE:${PN} = "enable" 
